#default packagegroup-base-nfc is neard, here replaced by nxp-nfc
RDEPENDS:packagegroup-base-nfc = "nxp-nfc"
