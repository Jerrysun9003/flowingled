# Copyright (C) 2023 PHILILPS OCEAN
# Copyright 2023 PHILILPS
# Released under the MIT license (see COPYING.MIT for the terms)

DESCRIPTION = "Philips Ocean Image to validate pacific machines. \
This image contains everything used to test philips machines including GUI, \
demos and lots of applications. This creates a very large image, not \
suitable for production."

require recipes-fsl/images/imx-image-multimedia.bb
